# Keil uVision project pj.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: pj +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\keil_v5\C51\INC\STC
  group Source Group 1
    ./: main.c GPIO.c NVIC.c UART.c Delay.c UART_Isr.c
